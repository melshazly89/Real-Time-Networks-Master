# Keil uVision project Lab2.uvprojx, settings and files
target Target (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Lab2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: Lab2.c osasm.s os.c
    ../inc/: BSP.c Profile.c
  group Object
    ./: texas.o
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
